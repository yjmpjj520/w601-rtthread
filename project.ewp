# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: __inline=inline; __inline__=inline; RT_USING_DLIBC; _DLIB_FILE_DESCRIPTOR; __RTTHREAD__
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\components\libc\compilers\common; oneshot; ..\..\include; ..\..\libcpu\arm\common; ..\..\components\drivers\include; ..\..\components\dfs\filesystems\devfs; ..\..\components\libc\posix\ipc; ..\..\components\finsh; drivers; ..\..\components\net\lwip\lwip-2.0.3\src\include\netif; .; ..\..\components\net\lwip\lwip-2.0.3\src\include; ..\..\components\utilities\ulog; ..\..\libcpu\arm\cortex-m3; ..\..\components\net\sal\include\dfs_net; ..\..\components\drivers\hwcrypto; ..\..\components\dfs\include; ..\..\components\drivers\spi; applications; ..\..\components\net\netdev\include; ..\..\components\net\lwip\lwip-2.0.3\src\include\ipv4; ..\..\components\net\lwip\port; ..\..\components\net\lwip-dhcpd; ..\..\components\net\sal\include\socket\sys_socket; ..\..\components\libc\compilers\common\extension; ..\..\components\net\sal\include; ..\..\components\net\sal\impl; ..\..\components\libc\posix\io\poll; ..\..\components\libc\posix\io\stdio; ..\..\components\drivers\wlan; ..\..\components\net\sal\include\socket
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ../../rtthread.bin
  postbuild: cmd /c "makeimg.bat"
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkIcfFile: .\drivers\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCOptLevel: 3
  group Applications
    applications/: main.c
  group Compiler
    ../../components/libc/compilers/common/: stdlib.c time.c
    ../../components/libc/compilers/dlib/: syscall_remove.c syscall_open.c syscall_lseek.c syscall_close.c syscalls.c syscall_write.c syscall_read.c syscall_mem.c environ.c
  group CPU
    ../../libcpu/arm/common/: backtrace.c div0.c showmem.c
    ../../libcpu/arm/cortex-m3/: context_iar.S cpuport.c
  group DeviceDrivers
    ../../components/drivers/hwcrypto/: hw_hash.c hw_rng.c hw_crc.c hw_symmetric.c hw_bignum.c hwcrypto.c
    ../../components/drivers/hwtimer/: hwtimer.c
    ../../components/drivers/i2c/: i2c_core.c i2c_dev.c i2c-bit-ops.c
    ../../components/drivers/ipc/: workqueue.c ringblk_buf.c waitqueue.c ringbuffer.c dataqueue.c pipe.c completion.c
    ../../components/drivers/misc/: rt_drv_pwm.c pin.c
    ../../components/drivers/rtc/: soft_rtc.c rtc.c
    ../../components/drivers/serial/: serial.c
    ../../components/drivers/spi/: spi_core.c spi_dev.c
    ../../components/drivers/watchdog/: watchdog.c
    ../../components/drivers/wlan/: wlan_dev.c wlan_workqueue.c wlan_cfg.c wlan_prot.c wlan_lwip.c wlan_cmd.c wlan_mgnt.c
  group Drivers
    drivers/: pin_map.c drv_uart.c drv_pin.c drv_flash.c drv_wifi.c board.c
  group Filesystem
    ../../components/dfs/src/: dfs_posix.c dfs_fs.c dfs.c dfs_file.c
    ../../components/dfs/filesystems/devfs/: devfs.c
  group Finsh
    ../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group Kernel
    ../../src/: idle.c components.c scheduler.c irq.c object.c mem.c kservice.c mempool.c ipc.c clock.c device.c thread.c timer.c
  group lwIP
    ../../components/net/lwip/lwip-2.0.3/src/api/: netdb.c sockets.c netifapi.c tcpip.c netbuf.c api_lib.c err.c api_msg.c
    ../../components/net/lwip/lwip-2.0.3/src/core/: ip.c netif.c sys.c init.c memp.c raw.c tcp_out.c inet_chksum.c stats.c tcp_in.c dns.c timeouts.c udp.c pbuf.c def.c tcp.c
    ../../components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c ip4_addr.c dhcp.c etharp.c ip4.c ip4_frag.c icmp.c igmp.c
    ../../components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../../components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../../components/net/lwip/port/: ethernetif.c sys_arch.c
    ../../components/net/lwip-dhcpd/: dhcp_server_raw.c
  group oneshot
    oneshot/: oneshot.c
  group POSIX
    ../../components/libc/posix/io/poll/: select.c poll.c
  group SAL
    ../../components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../../components/net/sal/dfs_net/: dfs_net.c
    ../../components/net/sal/impl/: af_inet_lwip.c
    ../../components/net/sal/socket/: net_sockets.c net_netdb.c
    ../../components/net/sal/src/: sal_socket.c
  group Utilities
    ../../components/utilities/ulog/: ulog.c
    ../../components/utilities/ulog/backend/: console_be.c
