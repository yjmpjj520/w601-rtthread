# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: rtthread-w60x
  AfterMake: fromelf --bin !L --output rtthread.bin
  AfterMake: .\makeimg.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __STDC_LIMIT_MACROS, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__, WM_W600, RT_USING_ARM_LIBC
  c misc: --c99 --gnu
  c include: applications;rt-thread\components\libc\compilers\common\include;rt-thread\components\libc\compilers\common\extension;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\libcpu\arm\common;rt-thread\libcpu\arm\cortex-m3;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\drivers\spi;rt-thread\components\drivers\include;rt-thread\components\drivers\spi\sfud\inc;drivers;rt-thread\components\fal\inc;rt-thread\components\dfs\include;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\dfs\filesystems\elmfat;rt-thread\components\finsh;.;rt-thread\include;packages\wm_libraries-latest;packages\wm_libraries-latest\Include;packages\wm_libraries-latest\Include\Driver;packages\wm_libraries-latest\Platform\Drivers\spi;packages\wm_libraries-latest\Include\OS;packages\wm_libraries-latest\Include\Platform;packages\wm_libraries-latest\Include\OS;packages\wm_libraries-latest\Include\WiFi;packages\wm_libraries-latest\Platform\Inc;packages\wm_libraries-latest\Platform\Common\Params;packages\wm_libraries-latest\Platform\Common\crypto;packages\wm_libraries-latest\Platform\Common\crypto\digest;packages\wm_libraries-latest\Platform\Common\crypto\math;packages\wm_libraries-latest\Platform\Common\crypto\symmetric;packages\wm_libraries-latest\Platform\Boot\gcc;rt-thread\components\libc\posix\io\poll;rt-thread\components\libc\posix\io\stdio;rt-thread\components\libc\posix\ipc;rt-thread\components\utilities\ulog
  memory RVCT4: ROM 0x8010100 size 0xefeff
  memory RVCT9: RAM 0x20000000 size 0x28000
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: backtrace.c div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c spi_flash_sfud.c
  group Drivers
    drivers/: pin_map.c drv_uart.c drv_spi.c drv_pin.c drv_flash.c drv_spi_flash.c board.c
  group Fal
    rt-thread/components/fal/src/: fal.c fal_flash.c fal_rtt.c fal_flash_sfud_port.c fal_partition.c fal_flash_w601_port.c
  group Filesystem
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler.c thread.c timer.c
  group Libraries
    packages/wm_libraries-latest/Platform/Drivers/spi/: wm_hostspi.c
    packages/wm_libraries-latest/Platform/Common/crypto/pubkey/: pkcs.c dh.c pubkey.c wm_crypto_rsa.c ecc.c
    packages/wm_libraries-latest/Platform/Common/crypto/digest/: wm_crypto_sha512.c sha224.c wm_crypto_md4.c wm_crypto_hmac.c sha384.c wm_crypto_md2.c
    packages/wm_libraries-latest/rtthread/startup/armcc/: startup_venus.S
    packages/wm_libraries-latest/Platform/Drivers/gpio/: wm_gpio_afsel.c wm_gpio.c
    packages/wm_libraries-latest/Platform/Common/crypto/keyformat/: wm_crypto_base64.c wm_crypto_x509.c asn1.c
    packages/wm_libraries-latest/Platform/Drivers/timer/: wm_timer.c
    packages/wm_libraries-latest/Platform/Common/crypto/symmetric/: idea.c des3.c rc2.c aesGCM.c seed.c
    packages/wm_libraries-latest/Platform/Drivers/cpu/: wm_cpu.c
    packages/wm_libraries-latest/Platform/Drivers/rtc/: wm_rtc.c
    packages/wm_libraries-latest/Platform/Drivers/i2c/: wm_i2c.c
    packages/wm_libraries-latest/Platform/Drivers/pwm/: wm_pwm.c
    packages/wm_libraries-latest/Platform/Common/crypto/prng/: prng.c yarrow.c
    packages/wm_libraries-latest/Platform/Drivers/efuse/: wm_efuse.c
    packages/wm_libraries-latest/Platform/Common/fwup/: wm_fwup.c
    packages/wm_libraries-latest/Platform/Drivers/dma/: wm_dma.c
    packages/wm_libraries-latest/Platform/Drivers/internalflash/: wm_internal_fls.c
    packages/wm_libraries-latest/Platform/Drivers/irq/: wm_irq.c
    packages/wm_libraries-latest/rtthread/: rtthread_patch.c
    packages/wm_libraries-latest/Platform/Drivers/io/: wm_io.c
    packages/wm_libraries-latest/Platform/Common/crypto/: wm_crypto_hard.c
    packages/wm_libraries-latest/Platform/Drivers/pmu/: wm_pmu.c
    packages/wm_libraries-latest/Platform/Drivers/flash/: wm_fls.c wm_fls_gd25qxx.c
    packages/wm_libraries-latest/Platform/Drivers/adc/: wm_adc.c
    packages/wm_libraries-latest/Platform/Drivers/watchdog/: wm_watchdog.c
    packages/wm_libraries-latest/Platform/Common/Params/: wm_param.c
    packages/wm_libraries-latest/rtthread/utils/: utils.c
    packages/wm_libraries-latest/Platform/Boot/armcc/: misc.c
    packages/wm_libraries-latest/Platform/Common/crypto/math/: pstm_mul_comba.c
    packages/wm_libraries-latest/Lib/Wlan/: libwlan_mdk.lib
  group Utilities
    rt-thread/components/utilities/ulog/backend/: console_be.c
    rt-thread/components/utilities/ulog/: ulog.c
